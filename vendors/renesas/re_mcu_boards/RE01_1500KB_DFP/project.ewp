# IAR project project.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7F0E015D2CFB Renesas R7F0E015D2CFB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS\; CMSIS\Core\include; CMSIS\Driver\Include; Device; Device\CMSIS_Driver\Include; Device\Config; Device\Driver\Include; CMSIS\DSP\Include; CMSIS\DSP\PrivateInclude; Device\Driver\Src\r_usb_basic_mini\driver\inc; Device\Driver\Src\r_usb_basic_mini\hw\inc; Device\Driver\Src\r_usb_pmsc_mini\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.mot
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\RE01_1500KB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group CMSIS/Core/Include
    CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h
  group CMSIS/Driver/Include
    CMSIS/Driver/Include/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_Storage.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h
  group CMSIS/DSP/Include
    CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h
  group CMSIS/DSP/PrivateInclude
    CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c
  group CMSIS/DSP/Source/BayesFunctions
    CMSIS/DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f32.c
  group CMSIS/DSP/Source/CommonTables
    CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c arm_mve_tables.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group CMSIS/DSP/Source/ControllerFunctions
    CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group CMSIS/DSP/Source/DistanceFunctions
    CMSIS/DSP/Source/DistanceFunctions/: arm_boolean_distance.c arm_boolean_distance_template.h arm_braycurtis_distance_f32.c arm_canberra_distance_f32.c arm_chebyshev_distance_f32.c arm_cityblock_distance_f32.c arm_correlation_distance_f32.c arm_cosine_distance_f32.c arm_dice_distance.c arm_euclidean_distance_f32.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c
  group CMSIS/DSP/Source/FastMathFunctions
    CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f32.c arm_vlog_f32.c
  group CMSIS/DSP/Source/FilteringFunctions
    CMSIS/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group CMSIS/DSP/Source/MatrixFunctions
    CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group CMSIS/DSP/Source/StatisticsFunctions
    CMSIS/DSP/Source/StatisticsFunctions/: arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f32.c arm_max_f32.c arm_max_no_idx_f32.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f32.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f32.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_power_f32.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group CMSIS/DSP/Source/SupportFunctions
    CMSIS/DSP/Source/SupportFunctions/: arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f32.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_fill_f32.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c arm_weighted_sum_f32.c
  group CMSIS/DSP/Source/SVMFunctions
    CMSIS/DSP/Source/SVMFunctions/: arm_svm_linear_init_f32.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f32.c
  group CMSIS/DSP/Source/TransformFunctions
    CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group Device
    Device/: pin.c pin.h RE01_1500KB.h startup_RE01_1500KB.c system_RE01_1500KB.c system_RE01_1500KB.h
  group Device/CMSIS_Driver/Include
    Device/CMSIS_Driver/Include/: R_Driver_I2C.h R_Driver_USART.h r_i2c_cmsis_api.h r_spi_cmsis_api.h r_usart_cmsis_api.h
  group Device/CMSIS_Driver/Src
    Device/CMSIS_Driver/Src/: r_i2c_cmsis_api.c r_spi_cmsis_api.c r_usart_cmsis_api.c r_usb_cmsis_api.c
  group Device/Config
    Device/Config/: r_adc_cfg.h r_core_cfg.h r_dmac_cfg.h r_dtc_cfg.h r_flash_cfg.h r_gdt_cfg.h r_i2c_cfg.h r_lpm_cfg.h r_pmip_cfg.h r_smip_cfg.h r_spi_cfg.h r_system_cfg.h r_usart_cfg.h
  group Device/Driver/Include
    Device/Driver/Include/: r_adc_api.h r_dma_common_api.h r_dmac_api.h r_dtc_api.h r_flash_api.h r_flash_lowlevel.h r_flash_re01_1500kb.h r_gdt_api.h r_lpm_api.h r_pmip_api.h r_smip_api.h r_system_api.h
  group Device/Driver/Src/r_adc
    Device/Driver/Src/r_adc/: r_adc_api.c
  group Device/Driver/Src/r_dmac
    Device/Driver/Src/r_dmac/: r_dmac_api.c
  group Device/Driver/Src/r_dtc
    Device/Driver/Src/r_dtc/: r_dtc_api.c
  group Device/Driver/Src/r_ehc
    Device/Driver/Src/r_ehc/: r_ehc.c
  group Device/Driver/Src/r_flash
    Device/Driver/Src/r_flash/: r_flash_api.c r_flash_lowlevel.c
  group Device/Driver/Src/r_gdt
    Device/Driver/Src/r_gdt/: r_gdt_api.c
  group Device/Driver/Src/r_lpm
    Device/Driver/Src/r_lpm/: r_lpm_api.c
  group Device/Driver/Src/r_pmip
    Device/Driver/Src/r_pmip/: r_pmip_api.c
  group Device/Driver/Src/r_smip
    Device/Driver/Src/r_smip/: r_smip_api.c
  group Device/Driver/Src/r_system
    Device/Driver/Src/r_system/: r_system_api.c
  group Device/Driver/Src/r_usb_basic_mini/driver
    Device/Driver/Src/r_usb_basic_mini/driver/: r_usb_cdataio.c r_usb_clibusbip.c r_usb_pbc.c r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_pintfifo.c r_usb_pinthandler_usbip0.c r_usb_plibusbip.c r_usb_psignal.c r_usb_pstd_api.c r_usb_pstdfunction.c r_usb_pstdrequest.c
  group Device/Driver/Src/r_usb_basic_mini/driver/inc
    Device/Driver/Src/r_usb_basic_mini/driver/inc/: r_usb_basic_define.h r_usb_extern.h r_usb_typedef.h
  group Device/Driver/Src/r_usb_basic_mini/hw
    Device/Driver/Src/r_usb_basic_mini/hw/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_dma.c r_usb_e017_mcu.c r_usb_preg_abs.c r_usb_preg_access.c
  group Device/Driver/Src/r_usb_basic_mini/hw/inc
    Device/Driver/Src/r_usb_basic_mini/hw/inc/: r_usb_bitdefine.h r_usb_dmac.h r_usb_reg_access.h
  group Device/Driver/Src/r_usb_pmsc_mini
    Device/Driver/Src/r_usb_pmsc_mini/: r_media_driver_api.c r_usb_atapi_driver.c r_usb_pmsc_api.c r_usb_pmsc_driver.c
  group Device/Driver/Src/r_usb_pmsc_mini/inc
    Device/Driver/Src/r_usb_pmsc_mini/inc/: r_usb_patapi.h r_usb_pmsc.h
