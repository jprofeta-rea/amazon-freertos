# IAR project project.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7F0E01182CFP Renesas R7F0E01182CFP
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS\; CMSIS\Core\include; CMSIS\Driver\Include; Device; Device\CMSIS_Driver\Include; Device\Config; Device\Driver\Include; CMSIS\DSP_Lib\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.mot
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\RE01_256KB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group CMSIS/Core/Include
    CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h
  group CMSIS/Driver/Include
    CMSIS/Driver/Include/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_Storage.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h
  group CMSIS/DSP_Lib/Include
    CMSIS/DSP_Lib/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group Device
    Device/: pin.c pin.h RE01_256KB.h startup_RE01_256KB.c system_RE01_256KB.c system_RE01_256KB.h
  group Device/CMSIS_Driver/Include
    Device/CMSIS_Driver/Include/: R_Driver_I2C.h R_Driver_USART.h r_i2c_cmsis_api.h r_spi_cmsis_api.h r_usart_cmsis_api.h
  group Device/CMSIS_Driver/Src
    Device/CMSIS_Driver/Src/: r_i2c_cmsis_api.c r_spi_cmsis_api.c r_usart_cmsis_api.c
  group Device/Config
    Device/Config/: r_adc_cfg.h r_core_cfg.h r_dmac_cfg.h r_dtc_cfg.h r_flash_cfg.h r_gdt_cfg.h r_i2c_cfg.h r_lpm_cfg.h r_pmip_cfg.h r_smip_cfg.h r_spi_cfg.h r_system_cfg.h r_usart_cfg.h
  group Device/Driver/Include
    Device/Driver/Include/: r_adc_api.h r_dma_common_api.h r_dmac_api.h r_dtc_api.h r_flash_api.h r_flash_lowlevel.h r_flash_re01_256kb.h r_gdt_api.h r_lpm_api.h r_pmip_api.h r_smip_api.h r_system_api.h
  group Device/Driver/Src/r_adc
    Device/Driver/Src/r_adc/: r_adc_api.c
  group Device/Driver/Src/r_dmac
    Device/Driver/Src/r_dmac/: r_dmac_api.c
  group Device/Driver/Src/r_dtc
    Device/Driver/Src/r_dtc/: r_dtc_api.c
  group Device/Driver/Src/r_ehc
    Device/Driver/Src/r_ehc/: r_ehc.c
  group Device/Driver/Src/r_flash
    Device/Driver/Src/r_flash/: r_flash_api.c r_flash_lowlevel.c
  group Device/Driver/Src/r_gdt
    Device/Driver/Src/r_gdt/: r_gdt_api.c
  group Device/Driver/Src/r_lpm
    Device/Driver/Src/r_lpm/: r_lpm_api.c
  group Device/Driver/Src/r_pmip
    Device/Driver/Src/r_pmip/: r_pmip_api.c
  group Device/Driver/Src/r_smip
    Device/Driver/Src/r_smip/: r_smip_api.c
  group Device/Driver/Src/r_system
    Device/Driver/Src/r_system/: r_system_api.c
